# Keil uVision project 386_004_GUI_CardFirmware.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2468 NXP
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: 457_001_GUI_CardFirmware Rev01_0 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group 386_004_GUI Card Firmware
    ./: LPC2400.s CntrlCardIntrface.c ConfigureUc.c GUIC_Main.c KEYPAD_IntrFace.c LCD_IntrFace.c Peripheral_Intrfs.c XRAY_IRQ.c XRAY_LCD4BIT.C Rs485Communication.c NvmIntrface.c
